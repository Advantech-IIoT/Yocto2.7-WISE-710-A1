FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-add-for-wise-710-config-and-rtc-rx8010-driver.patch \
            file://0002-enable-r8169-driver.patch \
            "

