FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-add-platform-flavor-for-imx6dlwise710a1.patch"

